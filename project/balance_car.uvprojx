# Keil uVision project balance_car.uvprojx, settings and files
target stm32f103rct6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: balance_car +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Driver\Include;..\Driver\Source;..\STM32\core;..\STM32\driver\inc;..\STM32\driver\src;..\user;..\FreeRTOS\include;..\FreeRTOS\portable\ARM_CM3;..\FreeRTOS\source;..\Driver\Source\mpu6050;..\Driver\Source\mpu6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c stm32f10x_it.c FreeRTOSConfig.h
  group driver
    ../Driver/Source/: delay.c exti.c key.c lcd_fonts.c lcd_image.c lcd_model.c lcd_spi_169.c led.c usart.c balance.c robot.c sys.c encoder.c motor.c control.c light.c tasks.c rgb.c servo.c
    ../Driver/Source/mpu6050/: mpu6050.c mpu6050_dmp.c
    ../Driver/Source/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group stm32
    ../STM32/core/: startup_stm32f10x_hd.s system_stm32f10x.c
    ../STM32/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/portal
    ../FreeRTOS/portable/: heap_4.c
    ../FreeRTOS/portable/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
